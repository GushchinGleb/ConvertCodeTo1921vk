# Keil uVision project SFP28_SR.uvprojx, settings and files
target SFP28_SR_K1921VK035 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: K1921VK035 Generic
  pack: NIIET.K1921VK035_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SFP28_SR
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SYSCLK_OSI
  c include: .\CMSIS\Core\Include;.\CMSIS\Device\Include;.\bsp\NIIET-BB-K1921VK035
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ./CMSIS/Device/Source/: system_K1921VK035.c
    ./CMSIS/Device/Source/ARM/: startup_K1921VK035.s
  group src
    ./src/: main.c tick.c flash_if.c soft_slave_i2c.c soft_master_i2c.c MALD_37645.c MATA_37644.c
  group inc
    ./inc/: board.h flash_if.h sfp28.h tick.h MATA_37644.h MALD_37645.h soft_slave_i2c.h soft_master_i2c.h
