# Keil uVision project blinky.uvprojx, settings and files
target blinky_K1921VK035 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: K1921VK035 Generic
  pack: NIIET.K1921VK035_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RETARGET, SYSCLK_PLL, OSECLK_VAL=16000000
  c include: .\CMSIS\Core\Include;.\CMSIS\Device\Include;.\bsp\NIIET-BB-K1921VK035;..\blinky;.\Retarget
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group startup
    ./CMSIS/Device/Source/: system_K1921VK035.c
    ./CMSIS/Device/Source/ARM/: startup_K1921VK035.s
  group src
    ./src/: clock.c eeprom_a0a2.c flash_if.c i2c_master.c i2c_slave.c main.c masc37029.c tick.c
  group inc
    ./inc/: board.h eeprom_a0a2.h flash_if.h i2c_master.h i2c_slave.h masc37029.h sfp28.h tick.h
  group CMSIS
    ./CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
    ./CMSIS/Device/Include/: K1921VK035.h system_K1921VK035.h
    ./CMSIS/Device/Source/ARM/: startup_K1921VK035.s
    ./CMSIS/Device/Source/: system_K1921VK035.c
